COMPATIBLE_MACHINE_nxp-ls1046 = "nxp-ls1046"
TARGET_ARCH_FMLIB = "arm"
