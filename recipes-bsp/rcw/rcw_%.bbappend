COMPATIBLE_MACHINE_nxp-ls1046 = "nxp-ls1046"
M = "ls1046ardb"
