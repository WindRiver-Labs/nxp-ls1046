COMPATIBLE_MACHINE_nxp-ls1046 = "nxp-ls1046"
PPA_PATH_nxp-ls1046 = "ppa/soc-ls1046/platform-rdb"

