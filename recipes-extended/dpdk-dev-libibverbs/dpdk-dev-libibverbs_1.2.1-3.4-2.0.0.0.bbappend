COMPATIBLE_MACHINE_nxp-ls1046 = "nxp-ls1046"
COMPATIBLE_HOST_nxp-ls1046 = '(aarch64).*-linux'
