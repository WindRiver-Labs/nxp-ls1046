include ../images/do_make_nxp_ls1046_wic.inc
