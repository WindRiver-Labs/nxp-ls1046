#
# Copyright (C) 2018 Wind River Systems, Inc.
#

require linux-yocto-nxp-ls1046.inc

KBRANCH_nxp-ls1046 = "standard/nxp-ls/lsdk-1712/${KMACHINE}"
