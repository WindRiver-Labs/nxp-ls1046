#
# Copyright (C) 2018 Wind River Systems, Inc.
#

require linux-yocto-nxp-ls1046.inc

KBRANCH_nxp-ls1046 = "v4.18/standard/preempt-rt/nxp-ls/lsdk-1812/${KMACHINE}"
