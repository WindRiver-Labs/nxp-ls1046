#
# Copyright (C) 2016 Wind River Systems, Inc.
#

require linux-windriver-nxp-ls1046.inc
