#
# Copyright (C) 2018 Wind River Systems, Inc.
#

require linux-yocto-nxp-ls1046.inc

KBRANCH_nxp-ls1046 = "v5.2/standard/nxp-lsdk-20.04/nxp-ls1046"
